;P8000 SPEZIFISCHE PROGRAMMTEILE UND DATEN FUER DAS REMOTE-PAKET
;REM.P8000.S
 
	EXTERNAL RETURN
	GLOBAL SYSTEM LODTTY SNDTTY INIPTY RESPTY
	GLOBAL ACTCMD DEACT DATE
	GLOBAL HWINIT HWSTART
 
SYSTEM:	JP 1003H
 
LODTTY:
	CALL PRESS
	RET Z
	CALL GETA
	AND 7FH
	RET
SNDTTY:	RES 7,A
	JP PTYPUT
 
GETA: EQU 0BE8H
PTYPUT: EQU 0BEBH
PRESS: EQU 0BE5H
MCSQ:  EQU 0EF0H	;ESC/CTRL-S/Q-MERKER FUER GETA/PUTA
 
BRKFLG: EQU 0FC4H
BRKRTN: EQU 0FC5H
 
DATE:	DEFW 0FA2H
 
;------------------------------------------------------
 
ACTCMD:	DEFB 0
	DEFB 0
	DEFW COMSTR
	DEFW 0
	DEFW 0
	DEFW 0
	DEFB 0
	DEFW 0
COMSTR:	DEFM 'ACTIVATE $SI;DEFINE 19 $SI'
	DEFB 0DH
 
DEACT:	DEFB 0
	DEFB 0
	DEFW COM1ST
	DEFW 0
	DEFW 0
	DEFW 0
	DEFB 0
	DEFW 0
COM1ST:	DEFM 'DEACTIVATE $SI'
	DEFB 0DH
 
;-------------------------------------------------
 
INIPTY:
	LD HL,MCSQ
	SET 0,(HL)	;ESC/CTRL-S UND CTRL-Q WERDEN DURCHGEREICHT
	RET
 
RESPTY:
	LD HL,MCSQ
	RES 0,(HL)	;ALTE UDOS-SYSTEMZUSTAND HERSTELLEN
	RET
 
HWINIT:	RET
HWSTART: RET
 
BRKRET:	XOR A
	JP RETURN
